# Repository azasypkin/kroneum

File README.md:

# 🕐 Kroneum

**Disclaimer:** I needed a dumb, autonomous, configurable and GUI-less physical timer to better manage my own time during the day and that is how Kroneum was born. 
Another goal was to see how well Rust fits into embedded development (basic interactions with MCU, USB stack and I2C driver).

------------------------

**Kroneum** is an experimental, accessible (no GUI) and fully open source (both in code and hardware) time tracker device.

There is neither GUI/LCD nor Wi-Fi/Bluetooth interface available, just two buttons one can use to configure the timer. More advanced users can use built-in USB functionality
to configure device (via dedicated [CLI tool](./sw/cli) with optional Web interface), upgrade firmware (via [DFU interface](./sw/firmware/README.md)) or upload various Krouneum "recipes" (e.g. to repurpose device completely).

## Usage

By default device stays in a standby low power mode and wakes up as soon as any of the button is being pressed for 3-5 seconds. As mentioned above there are just two buttons: **Ⅰ** (Roman `one`) and **Ⅹ** (Roman `ten`).

* Long press on **Ⅰ** or **Ⅹ** button when in `StandBy` mode - device enters into `Setup` mode
* Short press on **Ⅰ** when in `Setup` mode - increases desired timer by one `unit`
* Short press on **Ⅹ** when in `Setup` mode - increases desired timer by ten `units`
* Long press on **Ⅰ** when in `Setup` mode - sets timer treating `unit` as a `second` (see example below)
* Long press on **Ⅹ** when in `Setup` mode - sets timer treating `unit` as a `minute` (see example below)
* Long press on both **Ⅰ** *and* **Ⅹ** when in `Setup` mode - sets timer treating `unit` as an `hour` (see example below)
* Long press on **Ⅰ** *or* **Ⅹ** when in `Alarm` mode - resets current alarm if any and enters `Setup` mode
* Long press on both **Ⅰ** *and* **Ⅹ** when in `Alarm` mode - resets current alarm if any and enters `StandBy` mode
* **Very** long press (5 seconds) on both **Ⅰ** *and* **Ⅹ** - enters `Configuration` mode and powers up USB interface

Once timer fires up it will be repeated every 10 seconds (configurable) until it's acknowledged by the long press on both **Ⅰ** *and* **Ⅹ**.

## Examples:

* Long Press on **Ⅰ** + 5 short presses on **Ⅰ** + long press on **Ⅰ** = `5s` timer
* Long Press on **Ⅰ** + 5 short presses on **Ⅰ** + long press on **Ⅹ** = `5m` timer
* Long Press on **Ⅰ** + 5 short presses on **Ⅰ** + long press on both **Ⅰ** *and* **Ⅹ** = `5h` timer
* Long Press on **Ⅰ** + 1 short press on **Ⅰ** + 2 short presses on *Ⅹ** + long press on **Ⅰ** = `21s` timer
* Long Press on **Ⅰ** + 1 short press on **Ⅹ** + long press on **Ⅹ** = `10m` timer
* and so on

## Configuration

Advanced users can configure device via USB with the help of dedicated [CLI tool](./sw/cli), assuming device is in `Configuration` mode and
connected to the host PC via micro USB cable:

```bash
$ cargo run -- info

$ cargo run -- beep -n5

$ cargo run -- alarm get
$ cargo run -- alarm set "5m 15s"

$ cargo run -- flash read 0x1f
$ cargo run -- flash write 0x1f 10
$ cargo run -- flash erase

$ cargo run -- reset

```

It's also possible to use CLI tool as a standalone server with a minimalistic Web interface:

```bash
$ cargo run -- ui
  Running Kroneum Web UI on http://127.0.0.1:8080
``` 

Web server is bound to a local `http://127.0.0.1:8080` address and can be accessed with any modern browser:

Run `cargo run -- help` for more details.

**NOTE:** To use CLI tool without `root` privilege you may need to add the following `udev` rule:
```
/etc/udev/rules.d/50-kroneum.rules
----------
SUBSYSTEMS=="usb", ATTRS{idVendor}=="1209", ATTRS{idProduct}=="deed", GROUP="users", MODE="0660"
```

And then manually force `udev` to trigger this rule:
```bash
# udevadm trigger
```

In the future releases Web interface will be using [WebHID API](https://wicg.github.io/webhid/) completely eliminating the need in
the local Web server.

## Building custom firmware

If you feel adventurous you can easily build and flash custom firmware to Kroneum. You can use `./scripts/flash.sh` script 
from [fw](./sw/firmware) folder to build and flash default firmware or few custom [examples](./sw/firmware/bin/examples):

Default firmware:
```bash
# Default firmware
$ ./scripts/flash.sh 

# Example: blinking through TP1/SDA pad exposed on the back side of Kroneum PCB
$ ./scripts/flash.sh blinky

# Example: interfacing with SSD1306 LCD via TP1/SDA and TP2/SCL pads exposed on the back side of Kroneum PCB
$ ./scripts/flash.sh i2c_ssd1306 
``` 

The `flash.sh` script is essentially consequent calls of `cargo build --release ...`, `cargo objcopy --release ...` and `dfu-util ...`.

## Prototype or DIY

Schematics is done in `KiCad` and can be found [here](./hw/pcb/Rev_0.5). PCB includes SWD, I2C and CR2032 connectors and may look a bit
oversized because of that, but on the bright side hand soldering and [CNC engraving](./hw/pcb/Rev_0.3/cnc) was a breeze.

The most recent enclosure was machined from 5mm (base and cap) and 2mm (buttons) Delrin and the older versions were machined from
5mm Plexiglas (walls and buttons) and 2mm Delrin (base and cap). G-Code can be found [here](./hw/enclosure/Rev_0.5/cnc).

See [PCB](./hw/pcb/Rev_0.6/demo) and [enclosure](./hw/enclosure/Rev_0.6/demo) renders and photos of how it turned in real:

#### Demo PCB and enclosure (rendered vs real)

<details>
  <summary><b>Older versions</b></summary>

</details>

-.- .-. --- -. . ..- --

## KiCad design hw/pcb/Rev_0.6/kroneum.kicad_pcb

Board: 2 copper layers, 30.0 x 30.0 mm, 31 parts (13 on the bottom side), 23 nets.

Parts:
ADC1, ADC3: Peripherals; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
BT1: Battery; LINX_BAT-HLD-001_0
BZ1: Buzzer; Buzzer_Murata_PKMCS0909E4000-R1
C1, C7, C8, C9: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C4: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 4.7u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: BAT54C; SOT-23
GND: Peripherals; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
J1: USB_B_Micro; USB_Micro-B_Molex-105017-0001
MISO: Peripherals; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
MOSI: Peripherals; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
NSS: Peripherals; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
R1: 470; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SCK: Peripherals; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
SCL: Peripherals; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
SDA: Peripherals; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
SW1: Boot_Mode_Btn; tl3342
SW2: Ctrl_One_Btn; tl3342
SW3: Reset_Btn; tl3342
SW4: Ctrl_Ten_Btn; tl3342
SWCLK: Peripherals; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
SWDIO: Peripherals; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
U1: STM32F042F4Px; TSSOP-20_4.4x6.5mm_P0.65mm
U2: MCP1700-3302E_SOT89; SOT-89-3
VDD: Peripherals; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm

Connections:
ADC1: ADC1.1, U1.7
ADC3: ADC3.1, U1.9
BOOT0: R2.1, SW1.1, U1.1
Buzzer: R1.2, U1.14
Ctrl_One: C8.2, SW2.1, U1.6
Ctrl_Ten: C9.2, SW4.1, U1.8
GND: BT1.2, BZ1.2, C1.2, C2.1, C3.2, C4.2, C7.2, GND.1, J1.5, J1.6, R2.2, SW3.2, U1.15, U2.1
MISO: MISO.1, U1.12
MOSI: MOSI.1, U1.13
NRST: C7.1, SW3.1, U1.4
NSS: NSS.1, U1.10
unnamed: BT1.1, D1.1
unnamed: BZ1.1, R1.1
unnamed: C4.1, D1.2, U2.3
SCK: SCK.1, U1.11
SCL: SCL.1, U1.3
SDA: SDA.1, U1.2
SWCLK: SWCLK.1, U1.20
SWDIO: SWDIO.1, U1.19
USB_D+: J1.3, U1.18
USB_D-: J1.2, U1.17
USB_VBUS: C2.2, J1.1, U2.2
VDD: C1.1, C3.1, C8.1, C9.1, D1.3, SW1.2, SW2.2, SW4.2, U1.5, U1.16, VDD.1

## KiCad design hw/pcb/Rev_0.4/kroneum.kicad_pcb

Board: 2 copper layers, 40.0 x 40.0 mm, 23 parts (4 on the bottom side), 17 nets.

Parts:
BT1: Battery_Cell; LINX_BAT-HLD-001_0
BZ1: Buzzer; Buzzer_Murata_PKMCS0909E4000-R1
Boot: Boot; tl3342
C1, C7, C8, C9: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C4: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 4.7u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: BAT54C; SOT-23
J1: USB_B_Micro; USB_Micro-B_Molex-105017-0001
One: One; tl3342
R1: 470; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Reset: Reset; tl3342
TP1, TP2, TP3, TP4: TestPoint; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
Ten: Ten; tl3342
U1: STM32F042F4Px; TSSOP-20_4.4x6.5mm_P0.65mm
U2: MCP1700-3302E_SOT89; SOT-89-3

Connections:
BOOT0: Boot.1, R2.1, U1.1
Buzzer: R1.2, U1.13
Ctrl_One: C8.2, One.1, U1.6
Ctrl_Ten: C9.2, Ten.1, U1.8
GND: BT1.2, BZ1.2, C1.2, C2.1, C3.2, C4.2, C7.2, J1.5, J1.6, R2.2, Reset.2, U1.15, U2.1
NRST: C7.1, Reset.1, U1.4
unnamed: BT1.1, D1.2
unnamed: BZ1.1, R1.1
unnamed: C4.1, D1.1, U2.3
SCL: TP2.1, U1.3
SDA: TP1.1, U1.2
SWCLK: TP3.1, U1.20
SWDIO: TP4.1, U1.19
USB_D+: J1.3, U1.18
USB_D-: J1.2, U1.17
USB_VBUS: C2.2, J1.1, U2.2
VDD: Boot.2, C1.1, C3.1, C8.1, C9.1, D1.3, One.2, Ten.2, U1.5, U1.16

## KiCad design hw/pcb/Rev_0.2/kroneum.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_LINX_BAT-HLD-012-SMT
BZ1: Buzzer; Buzzer_Murata_PKMCS0909E4000-R1
C1, C7, C8, C9: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C4: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 4.7u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: BAT54C; SOT-23
J1: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J2: SWD_I2C_BOOT; PinSocket_1x08_P2.54mm_Vertical
L1: HT7333-A; SOT-89-3
R1: 470; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: Boot_Mode_Btn; tl3342
SW2: Ctrl_One_Btn; tl3342
SW3: Reset_Btn; tl3342
SW4: Ctrl_Ten_Btn; tl3342
U1: STM32F042F4Px; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
BOOT0: J2.8, R2.1, SW1.1, U1.1 (PB8)
Buzzer: R1.2, U1.13 (PA7)
Ctrl_One: C8.2, SW2.1, U1.6 (PA0)
Ctrl_Ten: C9.2, SW4.1, U1.8 (PA2)
GND: BT1.2 (-), BZ1.2 (+), C1.2, C2.1, C3.2, C4.2, C7.2, J1.5 (GND), J2.1, L1.1 (GND), R2.2, SW3.2, U1.15 (VSSA)
NRST: C7.1, J2.5, SW3.1, U1.4 (NRST)
unnamed: BT1.1 (+), D1.2
unnamed: BZ1.1 (-), R1.1
unnamed: C4.1, D1.1, L1.3 (VOUT)
SCL: J2.6, U1.3 (PF1)
SDA: J2.7, U1.2 (PF0)
SWCLK: J2.4, U1.20 (PA14)
SWDIO: J2.3, U1.19 (PA13)
USB_D+: J1.3 (D+), U1.18 (PA10/PA12)
USB_D-: J1.2 (D-), U1.17 (PA9/PA11)
USB_VBUS: C2.2, J1.1 (VBUS), L1.2 (VIN)
VDD: C1.1, C3.1, C8.1, C9.1, D1.3, J2.2, SW1.2, SW2.2, SW4.2, U1.5 (VDDA), U1.16 (VDD)

Board: 2 copper layers, 50.0 x 40.0 mm, 20 parts (0 on the bottom side), 17 nets.

## Commit log (part)

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2018-12-25 Create schematics v1.
2018-12-29 Initial USB implementation.
2018-12-30 Add device descriptors.
2019-01-08 stm32f0x2: add missing `pa11_pa12_rmp` register and rename `usbrst` to `usben`.
2019-01-08 build: add backup binary images.
2019-01-08 cli: add cli skeleton.
2019-01-08 firmware: remove redundant Endpoint enum.
2019-01-09 firmware: move setup packet and descriptors into separate sub modules.
2019-01-09 firmware: fix descriptor string lengths.
2019-01-10 firmware: process incoming data for device endpoint (LED).
2019-01-11 hw: switch `ten-1` button from PA5 to PA0 to be able to wake up device from stand-by mode.
2019-01-12 firmware: toggle USB state on button click.
2019-01-12 firmware: do not store PMA reference in the app state.
2019-01-12 firmware: use HSI as main clock all the time, start/stop USB clock and device on demand only.
2019-01-12 firmware: replace start/stop with more appropriate setup/teardown.
2019-01-12 firmware: move USB clock management to USB module itself.
2019-01-13 firmware: use PA5 for blue LED and PA2 for x-button.
2019-01-14 firmware: enable standby mode when exiting from `Config` mode.
2019-01-14 firmware: introduce `System` module. Fix RTC Alarm to respect seconds, minutes and hours.
2019-01-14 firmware: make Beeper module internal detail of System module.
2019-01-15 hw: switch to Rev 0.2 of schematics (removed crystal).
2019-01-18 hw: add simple boot mode button circuit simulation.
2019-01-20 docs: add useful links to the README.
2019-01-24 hw: reorganize headers on PCB.
2019-01-26 hw: first PCB version with all nets connected.
2019-01-26 hw: pcb remove redundant traces.
2019-01-30 hw: decrease width of TSSOP20 pads, first export of Gerbers.
2019-02-02 hw: make all PCB holes 0.9mm.
2019-02-02 hw: prepare isolation, cutout and drilling NC files.
2019-02-10 firmware: add basic support for custom USB commands.
2019-02-11 cli: simplify Kroneum device structure.
2019-02-11 firmware: fix PMA IN address for the device endpoint.
2019-02-12 cli: switch to HIDAPI crate instead of libusb.
2019-02-13 cli: fix subcommand parsing logic.
2019-02-18 cli: simplify libusb device wrapper.
2019-02-19 cli: make it possible to interract with Kroneum using libusb and hidapi wrappers.
2019-02-21 hw: finish PCB Rev 0.3
2019-02-27 hw: include enclosure CNC files and 3d model.
2019-03-03 hw: adjust PCB manufacturing settings (add forgotten multidepth for cutout and increase drill and cutout depth).
2019-03-04 hw: update G-Code for the enclosure (multiple depth for adaptive, changed zero point for the cap).
2019-03-06 hw: move systick code to api crate + add unit tests.
2019-03-06 fw: generilize beeper code.
2019-03-08 fw: add `Buttons` tests.
2019-03-08 fw: add `BCDTime` struct and appropriate `From<Time>` implementations.
2019-03-08 fw: add BCDTime tests.
2019-03-08 fw: add `RTC` tests.
2019-03-08 fw: move `PMA` sub-module to API crate.
2019-03-08 fw: add basic USB descriptors tests.
2019-03-10 fw: move `USB` to API crate.
2019-03-10 fw: make alarm melody configurable.
2019-03-11 Add prototype screens.
2019-03-12 Initial CI setup.
2019-03-12 fw: remove default Cargo target.
2019-03-12 ci: run tests only for `kroneum-api` package.
2019-03-12 ci: return to the root folder once libusb is built.
2019-03-14 fw: migrate to `stm32f0` crate and ditch my own svd2rust generated device crate.
2019-03-14 fw: properly set timer when in USB configuration mode.
2019-03-14 fw: generalize write protection toggle in RTC module.
2019-03-15 fw: pass `Time` by value to `set_time` and `set_alarm`.
2019-03-17 Revert `RTFM migration` commit as RTFM does not allow sharing of SCB to manage DEEPSLEEP mode.
2019-03-18 fw: get rid of CorePeripherals dependency.
2019-03-20 fw: get rid of `acquire` patter for RTC and USB controllers.
2019-03-21 fw: simplify peripherals API.
2019-03-23 fw: move configure code from main to system.setup.
2019-03-23 cli: allow CLI to reset Kroneum device.
2019-03-24 fw: implement `usb::CommandPacket.to_bytes`.
2019-03-24 cli: use device vid/pid from kroneum_api.
2019-03-26 docs: include stm32f0 eeprom emulation application node.
2019-03-30 fw: add `erase_page` support.
2019-03-31 fw: refactor storage files.
2019-04-01 fw: implement `StoragePage.flush_to`.
2019-04-03 fw: do not map `()` to `()` when handling error.
2019-04-09 fw: add flash unit tests.
2019-04-09 fw: add system support for `CommandPackage::WriteFlash` handling.
2019-04-09 cli: add support for all flash operations.
2019-04-11 fw: remove `Buttons.toggle_wakers`.
2019-04-13 fw: start moving System members to API crate.
2019-04-17 Migrate Buttons tests to `crate::tests::MockData`.
2019-04-17 Migrate Flash tests to `crate::tests::MockData`.
2019-04-20 fw: rollback of `cortex-m` upgrade because of https://github.com/stm32-rs/stm32-rs/issues/184.
2019-04-21 fw: remove Systick dependency from `ButtonsHardware` trait.
2019-04-21 fw: add `usb` method to `SystemHardware`.
2019-04-21 fw: add `buttons` method to `SystemHardware`.
2019-04-21 fw: preparation to move `System` to API crate.
2019-04-24 fw: small cleanup in `RTCHardwareImpl`.
2019-04-24 fw: optimize `USBHardwareImpl`.
2019-04-25 fw: fix regression caused wrong statuses on control endpoint.
2019-05-01 fw: restructure Kroneum.
2019-05-07 Use dedicated and unique VID and PID: http://pid.codes/1209/DEED/.
2019-05-13 fw: properly teardown USB device to eliminite any leakage.
2019-05-14 ci: use proper syntax for the Travis Cargo cache.
2019-06-10 hw: introduce Rev 0.4 of PCB (changed LDO and its peripherals.
2019-06-11 fw: remove deprecated inclusive range syntax.
2019-06-22 hw: add rounded corners to the pcb edge.
2019-07-14 Add Rev_0.4 of enclosure.
2019-08-10 [cli] update dependencies.
2019-09-01 [fw] move away from `cortex-m` deprecated methods.
2019-09-08 [pcb] update SDW/SCL/SWCLK/SWDIO labels.
2019-09-08 [fw] add example with i2c + SSD1306 LCD.
2019-09-10 [fw] render line instead of text in i2c ssd1306 example fw.
2019-09-15 Move experiments to PKI example.
2019-09-15 [fw] use Rust Stable to compile firmware by default.
2019-09-29 [pcb] add Octopart BOM.
2019-10-16 [fw] switch buzzer output from PA7 to PB1 according to PCB Rev 0.6 to make PA7 available for SPI and I2S.
2019-11-26 [fw] improve reset melody.
2019-11-26 [ci] workaround Cargo bug https://github.com/rust-lang/cargo/issues/5015.
2019-12-22 [cli] drop `libusb` support.
2019-12-23 [cli] integrate eslint and prettier for the Web UI project. Merge `get_manufacturer` and `get_identifier` of Device struct.
2019-12-25 [fw] add support for USB command of arbitrary size (up to max packet size or 64 bytes).
2019-12-25 [cli/fw] improve custom melody handling code.
2019-12-26 [fw] add support for the `Echo` command.
2019-12-26 [cli] properly handle loading state of the Web UI.
2020-01-01 [cli] migrate to `actix-web` 2.0 and simplify module structure.
2020-01-05 [fw] switch to `panic-reset` to drastically reduce firmware size.
2020-01-11 [fw] Implement asynchronous button polling and audio.
2020-01-12 [docs] Include stm32 timers cookbook PDF.
2020-01-12 [hw] correct Readme layout.
2020-01-17 [doc] fix example firmware commands.
2020-02-04 [fw] update `stm32f0xx-hal` dependency.
2020-02-09 [cli] allow UI to read ADC values.
2020-02-22 [fw] add example with `nrf24l01` SPI driven radio.
2020-03-14 build(deps): bump acorn from 5.7.3 to 5.7.4 in /sw/cli/src/ui/static
    Bumps [acorn](https://github.com/acornjs/acorn) from 5.7.3 to 5.7.4.
    - [Release notes](https://github.com/acornjs/acorn/releases)
    - [Commits](https://github.com/acornjs/acorn/compare/5.7.3...5.7.4)
2020-03-19 [cli] update dependencies and check in Cargo lock files.
2020-03-19 [cli] update web UI dependencies.
2020-03-21 [cli] migrate to the latest USB API.
2020-03-22 [fw] add more test coverage for `Array` methods.
2020-04-06 [fw] Drop `CommandPacket::Unknown`.
2020-04-06 [fw] Drop radio `BeeperCommand::Unknown`.
2020-04-10 [cli] update JS dependencies.
2020-04-12 [cli] reorganized Web UI (introduced separate tabs).
2020-04-15 [docs] reorganize docs, add HID docs.
2020-04-18 [cli] add keyboard and media controls management UI.
2020-04-18 [cli] improve Key Modifiers support.
2020-04-18 [cli] update transient dependencies and fix linter warnings.
2020-04-20 [fw] implement system info USB command, retrieve stm32 device id.
2020-04-20 [docs] add docs for stm32 security and USB 101.
2020-04-20 [fw] introduce system roles.
2020-07-19 Bump lodash from 4.17.15 to 4.17.19 in /sw/cli/src/ui/static
    Bumps [lodash](https://github.com/lodash/lodash) from 4.17.15 to 4.17.19.
    - [Release notes](https://github.com/lodash/lodash/releases)
    - [Commits](https://github.com/lodash/lodash/compare/4.17.15...4.17.19)
2020-11-25 Bump highlight.js from 9.18.1 to 9.18.5 in /sw/cli/src/ui/static
    Bumps [highlight.js](https://github.com/highlightjs/highlight.js) from 9.18.1 to 9.18.5.
    - [Release notes](https://github.com/highlightjs/highlight.js/releases)
    - [Changelog](https://github.com/highlightjs/highlight.js/blob/9.18.5/CHANGES.md)
    - [Commits](https://github.com/highlightjs/highlight.js/compare/9.18.1...9.18.5)
2021-03-31 Bump y18n from 4.0.0 to 4.0.1 in /sw/cli/src/ui/static
    Bumps [y18n](https://github.com/yargs/y18n) from 4.0.0 to 4.0.1.
    - [Release notes](https://github.com/yargs/y18n/releases)
    - [Changelog](https://github.com/yargs/y18n/blob/master/CHANGELOG.md)
    - [Commits](https://github.com/yargs/y18n/commits)
2021-05-25 Bump browserslist from 4.10.0 to 4.16.6 in /sw/cli/src/ui/static
    Bumps [browserslist](https://github.com/browserslist/browserslist) from 4.10.0 to 4.16.6.
    - [Release notes](https://github.com/browserslist/browserslist/releases)
    - [Changelog](https://github.com/browserslist/browserslist/blob/main/CHANGELOG.md)
    - [Commits](https://github.com/browserslist/browserslist/compare/4.10.0...4.16.6)
2022-02-12 Bump ajv from 6.12.0 to 6.12.6 in /sw/cli/src/ui/static
    Bumps [ajv](https://github.com/ajv-validator/ajv) from 6.12.0 to 6.12.6.
    - [Release notes](https://github.com/ajv-validator/ajv/releases)
    - [Commits](https://github.com/ajv-validator/ajv/compare/v6.12.0...v6.12.6)
    ---
    updated-dependencies:
    - dependency-name: ajv
2022-04-09 Bump moment from 2.24.0 to 2.29.2 in /sw/cli/src/ui/static
    Bumps [moment](https://github.com/moment/moment) from 2.24.0 to 2.29.2.
    - [Release notes](https://github.com/moment/moment/releases)
    - [Changelog](https://github.com/moment/moment/blob/develop/CHANGELOG.md)
    - [Commits](https://github.com/moment/moment/compare/2.24.0...2.29.2)
    ---
    updated-dependencies:
2022-06-08 Bump miow from 0.2.1 to 0.2.2 in /sw/cli
    Bumps [miow](https://github.com/yoshuawuyts/miow) from 0.2.1 to 0.2.2.
    - [Release notes](https://github.com/yoshuawuyts/miow/releases)
    - [Changelog](https://github.com/yoshuawuyts/miow/blob/master/CHANGELOG.md)
    - [Commits](https://github.com/yoshuawuyts/miow/compare/0.2.1...0.2.2)
    ---
    updated-dependencies:
2022-06-16 Bump arc-swap from 0.4.5 to 0.4.8 in /sw/cli
    Bumps [arc-swap](https://github.com/vorner/arc-swap) from 0.4.5 to 0.4.8.
    - [Release notes](https://github.com/vorner/arc-swap/releases)
    - [Changelog](https://github.com/vorner/arc-swap/blob/v0.4.8/CHANGELOG.md)
    - [Commits](https://github.com/vorner/arc-swap/compare/v0.4.5...v0.4.8)
    ---
    updated-dependencies:
2022-06-17 Bump smallvec from 1.3.0 to 1.8.0 in /sw/cli
    Bumps [smallvec](https://github.com/servo/rust-smallvec) from 1.3.0 to 1.8.0.
    - [Release notes](https://github.com/servo/rust-smallvec/releases)
    - [Commits](https://github.com/servo/rust-smallvec/compare/v1.3.0...v1.8.0)
    ---
    updated-dependencies:
    - dependency-name: smallvec
2022-07-07 Bump moment from 2.24.0 to 2.29.4 in /sw/cli/src/ui/static
    Bumps [moment](https://github.com/moment/moment) from 2.24.0 to 2.29.4.
    - [Release notes](https://github.com/moment/moment/releases)
    - [Changelog](https://github.com/moment/moment/blob/develop/CHANGELOG.md)
    - [Commits](https://github.com/moment/moment/compare/2.24.0...2.29.4)
    ---
    updated-dependencies:
